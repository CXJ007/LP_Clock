# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32L432KCUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  AfterMake: .\keil5_disp_size_bar.exe
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32L432xx, __STDC_LIMIT_MACROS, USE_HAL_DRIVER, RT_USING_ARMLIBC, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__
  c include: packages\CMSIS-Core-latest\Include;applications;..\libraries\HAL_Drivers\drivers;board;..\..\components\drivers\usb\cherryusb\core;..\..\components\drivers\usb\cherryusb\class\cdc;.;..\..\components\libc\posix\io\eventfd;board\CubeMX_Config\Inc;..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\components\drivers\usb\cherryusb\class\vendor\serial;..\..\components\drivers\usb\cherryusb\class\dfu;..\..\include;..\..\components\drivers\usb\cherryusb\class\midi;..\..\components\drivers\include;..\..\components\drivers\usb\cherryusb\class\hid;..\..\components\drivers\include;packages\stm32l4_cmsis_driver-latest\Include;..\..\components\drivers\usb\cherryusb\class\vendor\net;..\..\components\libc\posix\ipc;..\libraries\HAL_Drivers;..\..\components\drivers\usb\cherryusb\osal;..\..\components\finsh;..\..\components\drivers\usb\cherryusb\common;..\..\components\drivers\usb\cherryusb\class\audio;..\..\components\libc\posix\io\poll;..\..\libcpu\arm\common;..\..\components\libc\compilers\common\extension;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\libc\posix\io\epoll;packages\cpu_usage-latest;packages\cherry_vcom\inc;..\..\components\drivers\usb\cherryusb\class\wireless;..\..\components\drivers\include;packages\stm32l4_hal_driver-latest\Inc;..\libraries\HAL_Drivers\drivers\config;packages\bh1750fvi\inc;..\..\components\drivers\include;..\..\components\libc\compilers\common\include;..\..\components\drivers\usb\cherryusb\class\video;..\..\components\drivers\usb\cherryusb\class\msc;..\..\libcpu\arm\cortex-m4
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group CherryUSB
    ../../components/drivers/usb/cherryusb/core/: usbd_core.c
    ../../components/drivers/usb/cherryusb/platform/rtthread/: usb_msh.c usb_check.c
    ../../components/drivers/usb/cherryusb/port/fsdev/: usb_dc_fsdev.c
    ../../components/drivers/usb/cherryusb/class/cdc/: usbd_cdc.c
    ../../components/drivers/usb/cherryusb/osal/: usb_osal_rtthread.c
  group Compiler
    ../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group cpu_usage
    packages/cpu_usage-latest/: cpu_usage.c cpu_usage_cmd.c
  group DeviceDrivers
    ../../components/drivers/core/: device.c
    ../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/pin/: dev_pin.c
    ../../components/drivers/rtc/: dev_alarm.c dev_rtc.c dev_soft_rtc.c
    ../../components/drivers/sensor/v1/: sensor.c
    ../../components/drivers/serial/: serial.c
  group Drivers
    board/CubeMX_Config/Src/: stm32l4xx_hal_msp.c
    board/: board.c
    ../libraries/HAL_Drivers/drivers/: drv_gpio.c drv_soft_i2c.c
    ../libraries/HAL_Drivers/: drv_common.c
  group Finsh
    ../../components/finsh/: msh.c msh_parse.c cmd.c shell.c
  group Kernel
    ../../src/: clock.c components.c cpu_up.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Peripheral
    packages/bh1750fvi/src/: bh1750fvi.c
    packages/cherry_vcom/src/: cherry_vcom.c
  group STM32L4-CMSIS
    packages/stm32l4_cmsis_driver-latest/Source/Templates/arm/: startup_stm32l432xx.s
    packages/stm32l4_cmsis_driver-latest/Source/Templates/: system_stm32l4xx.c
  group STM32L4-HAL
    packages/stm32l4_hal_driver-latest/Src/: stm32l4xx_hal_exti.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_comp.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_usart.c stm32l4xx_hal_cortex.c stm32l4xx_hal_uart.c stm32l4xx_hal_rcc.c stm32l4xx_hal_dma.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal.c stm32l4xx_hal_rtc.c stm32l4xx_hal_pwr.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_rng.c
